.title KiCad schematic
.include "../models/1N5818.mod"
.include "../models/TL074.mod"
XU2 Net-_R5-Pad2_ Net-_R5-Pad2_ Net-_R23-Pad2_ +v Net-_R24-Pad2_ Net-_R6-Pad2_ Net-_R6-Pad2_ Net-_R7-Pad2_ Net-_R7-Pad2_ Net-_R18-Pad1_ -v Net-_R17-Pad1_ Net-_R8-Pad2_ Net-_R8-Pad2_ TL074
R23 InputBus2 Net-_R23-Pad2_ 100k
R24 InputBus2 Net-_R24-Pad2_ 100k
R15 InputBus1 GND 1M
R10 Net-_R10-Pad1_ InputBus1 100k
R16 Net-_R16-Pad1_ InputBus1 100k
R9 Net-_R9-Pad1_ InputBus1 100k
R6 Output6 Net-_R6-Pad2_ 1k
R5 Output5 Net-_R5-Pad2_ 1k
R7 Output7 Net-_R7-Pad2_ 1k
R8 Output8 Net-_R8-Pad2_ 1k
R21 Net-_R21-Pad1_ InputBus4 100k
R12 Output12 Net-_R12-Pad2_ 1k
R22 Net-_R22-Pad1_ InputBus4 100k
R17 Net-_R17-Pad1_ InputBus3 100k
R18 Net-_R18-Pad1_ InputBus3 100k
R19 Net-_R19-Pad1_ InputBus3 100k
R20 Net-_R20-Pad1_ InputBus4 100k
D1 +v GND 1N5818
D2 GND -v 1N5818
XU3 Net-_R11-Pad2_ Net-_R11-Pad2_ Net-_R19-Pad1_ +v Net-_R20-Pad1_ Net-_R14-Pad2_ Net-_R14-Pad2_ Net-_U3-Pad8_ Net-_U3-Pad8_ Net-_R21-Pad1_ -v Net-_R22-Pad1_ Net-_R12-Pad2_ Net-_R12-Pad2_ TL074
R13 Output11 Net-_R12-Pad2_ 1k
R14 Output10 Net-_R14-Pad2_ 1k
R11 Output9 Net-_R11-Pad2_ 1k
XU1 Net-_R1-Pad2_ Net-_R1-Pad2_ Net-_R9-Pad1_ +v Net-_R10-Pad1_ Net-_R2-Pad2_ Net-_R2-Pad2_ Net-_R3-Pad2_ Net-_R3-Pad2_ Net-_R16-Pad1_ -v InputBus2 Net-_R4-Pad2_ Net-_R4-Pad2_ TL074
C7 +v GND 10uf
C4 -v GND 0.1uf
C1 +v GND 0.1uf
C6 -v GND 0.1uf
C5 +v GND 0.1uf
C3 +v GND 0.1uf
C2 -v GND 0.1uf
C8 GND -v 10uf
R4 Output4 Net-_R4-Pad2_ 1k
R2 Output2 Net-_R2-Pad2_ 1k
R3 Output3 Net-_R3-Pad2_ 1k
Vin1 InputBus1 GND dc 0 sin(0v 3v 1k)
R1 Output1 Net-_R1-Pad2_ 1k
.op
.control
.options rshunt=100M gmin=10n
tran 100us 10ms 0s
hardcopy plots/BufferedMultiple_InputBus1.ps V(InputBus1)
hardcopy plots/BufferedMultiple_Output1.ps V(Output1)
hardcopy plots/BufferedMultiple_Output2.ps V(Output2)
hardcopy plots/BufferedMultiple_Output3.ps V(Output3)
hardcopy plots/BufferedMultiple_+v.ps V(+v)
hardcopy plots/BufferedMultiple_-v.ps V(-v)
.endc
.end
